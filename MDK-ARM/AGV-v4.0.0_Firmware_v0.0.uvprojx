# Keil uVision project AGV-v4.0.0_Firmware_v0.0.uvprojx, settings and files
target AGV-v4.0.0_Firmware_v0.0 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: AGV-v4.0.0_Firmware_v0.0
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c misc: --C99
  c include: ../Inc;     ../Drivers/STM32F7xx_HAL_Driver/Inc;     ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;     ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;     ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;     ../Middlewares/Third_Party/FreeRTOS/Source/include;     ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;     ../Drivers/CMSIS/Include;     ../Middlewares/Third_Party/FatFs/src;     ../Middlewares/Third_Party/LwIP/src/include;     ../Middlewares/Third_Party/LwIP/system;     ../Middlewares/Third_Party/LwIP/src/include/lwip;     ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;     ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;     ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;     ../Middlewares/Third_Party/LwIP/src/include/netif;     ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;     ../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;     ../Middlewares/Third_Party/LwIP/src/include/posix;     ../Middlewares/Third_Party/LwIP/src/include/posix/sys;     ../Middlewares/Third_Party/LwIP/system/arch;     ..\UserLib\AGV
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: list.c croutine.c event_groups.c tasks.c queue.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_uart.c stm32f7xx_hal_pwr.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rtc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_gpio.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_tim.c stm32f7xx_hal_dma.c stm32f7xx_hal_rtc_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sram.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_eth.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group UserLib
    ../UserLib/AGV/: AGV_Followline.c IO.c AGVConfig.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: pppos.c auth.c ipv6cp.c mppe.c chap-md5.c ccp.c upap.c pppol2tp.c pppcrypt.c pppoe.c chap_ms.c ppp.c fsm.c utils.c lcp.c eap.c demand.c ecp.c eui64.c vj.c pppapi.c ipcp.c chap-new.c magic.c multilink.c
    ../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c slipif.c ethernet.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: icmp6.c ip6_frag.c ip6.c mld6.c ethip6.c ip6_addr.c dhcp6.c inet6.c nd6.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_msg.c netifapi.c netdb.c sockets.c err.c netbuf.c api_lib.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: timeouts.c dns.c init.c inet_chksum.c pbuf.c stats.c memp.c sys.c netif.c tcp_in.c ip.c udp.c tcp_out.c raw.c def.c mem.c tcp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: igmp.c ip4_frag.c icmp.c dhcp.c autoip.c etharp.c ip4_addr.c ip4.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: md5.c des.c md4.c arc4.c sha1.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Application/User
    ../Src/: main.c bsp_driver_sd.c sdmmc.c gpio.c ethernetif.c lwip.c adc.c stm32f7xx_hal_msp.c rtc.c fatfs.c usart.c spi.c sd_diskio.c stm32f7xx_it.c freertos.c
software components: CMSIS:CORE 5.0.2
